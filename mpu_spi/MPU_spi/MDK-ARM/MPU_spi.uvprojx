# Keil uVision project MPU_spi.uvprojx, settings and files
target MPU_spi (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MPU_spi
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xE
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32L1xx_HAL_Driver/Inc;  ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;  ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_tim.c stm32l1xx_hal_dma.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_gpio.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c freertos.c stm32l1xx_hal_timebase_TIM.c
    ../../../../: spi.c MPU9250.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.1.0
